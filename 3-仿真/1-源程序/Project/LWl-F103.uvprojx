# Keil uVision project LWl-F103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LWl-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\Libaraies\CMSIS;..\Libaraies\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\bsp-lcd1602;..\User\SysTick;..\User\ADC;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM;..\User\18b20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group STARTUP
    ../Libaraies/CMSIS/startup/: startup_stm32f10x_ld.s
  group CMSIS
    ../Libaraies/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libaraies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/bsp-lcd1602/: bsp-lcd1602.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/18b20/: ds18b20.c
    ../User/ADC/: adc.c
  group DOC
    ../Doc/: Readme.txt
  group SYSTEM
    ../SYSTEM/sys/: sys.c
